# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F407ZG (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Driver;..\Libraries\inc;..\System;..\User;..\uCOS-III\Bsp;..\uCOS-III\Config;..\uCOS-III\Core;..\uCOS-III\CPU;..\uCOS-III\Lib;..\uCOS-III\Port
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../Doc/: readme.txt
  group Core
    ../Core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group System
    ../System/: explore_system.c explore_systick.c explore_usart.c
  group Driver
    ../Driver/: driver_led.c
  group uC/OS III - BSP
    ../uCOS-III/Bsp/: bsp.c
  group uC/OS III - CPU
    ../uCOS-III/CPU/: cpu_core.c cpu_c.c cpu_a.asm
  group uC/OS III - Lib
    ../uCOS-III/Lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC/OS III - Core
    ../uCOS-III/Core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS III - Port
    ../uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS III - Config
    ../uCOS-III/Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group User
    ../User/: stm32f4xx_main.c stm32f4xx_conf.h stm32f4xx_it.c
